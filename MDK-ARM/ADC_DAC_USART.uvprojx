# Keil uVision project ADC_DAC_USART.uvprojx, settings and files
target ADC_DAC_USART (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC_DAC_USART
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_dac_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dac.c stm32l1xx_hal_flash.c stm32l1xx_hal_pwr.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Application/User
    ../Src/: stm32l1xx_hal_msp.c stm32l1xx_it.c main.c
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
software components: CMSIS:CORE 4.1.0
